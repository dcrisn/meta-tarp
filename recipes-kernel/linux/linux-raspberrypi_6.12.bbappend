# add kernel configuration fragments here that are PLATFORM-AGNOSTIC.
FILESEXTRAPATHS:prepend := "${THISDIR}/configs/:"

#SRC_URI += "file://defconfig"
